#XXX: adust /put elsewhere?
PACKAGECONFIG := "rootless"

BBCLASSEXTEND = "native"
