
IMAGE_FSTYPES = "container oci"
PREFERRED_PROVIDER_virtual/kernel = "dummy"

inherit image
inherit image-oci

IMAGE_LINGUAS = ""
NO_RECOMMENDTIONS = "1"
IMAGE_FEATURES = ""
ROOTFS_BOOTSTRAP_INSTALL = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
